## board/praxis/tftdevice/Kconfig
```kconfig
if TARGET_TFTDEVICE

config SYS_BOARD
	default "tftdevice"

config SYS_VENDOR
	default "praxis"

config SYS_CONFIG_NAME
	default "tftdevice"

endif
```
